Properties of the parts of a building model (IFC2X3)

# File
Description: IFC2X3
File name: DRACO_80.300_VÁLVULA_DESCARGA_ANTIVANDÁLICA_PÓLUX.IFC
Time: 2022-07-08T19:52:35
Written by: SwIFC
Made in: SolidWorks 2019

# IfcSite, Default Site
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0

# IfcBuildingStorey, Default Storey
In: Default Building
Elevation: 0

# IfcBeam: DRACO_80.300_1_CAIXA_BASE_PÓLUX
In: Default Storey
Material: ABS

# IfcBeam: DRACO_80.300_2_TAMPA_DESCARGA_PÓLUX
In: Default Storey
Material: Brass
